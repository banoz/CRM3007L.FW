# Keil uVision project CRM3007L.uvproj, settings and files
target OB38R16T1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: CRM3007L +hex
  c flags: Optimize=8 SizeSpeed=1
  group Core
    ./: STARTUP.A51 OB38R16T1.h
  group HAL
    ./HAL/: ADC.h ADC.c timer.c timer.h IIC.c IIC.h WDT.c WDT.h PWM.c PWM.h UART.c UART.h
  group Application
    ./: main.c
  group BSP
    ./: board.c board.h sensors.c sensors.h
